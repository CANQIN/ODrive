# Keil uVision project ODrive.uvprojx, settings and files
target ODrive (6210000::V6.21::.\ARMCompilerV621)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ODrive +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F405xx,ARM_MATH_CM4,FPU_FPV4,HW_VERSION_MAJOR=3,HW_VERSION_MINOR=6,HW_VERSION_VOLTAGE=56,FIBRE_ENABLE_SERVER=1
  c misc: -Wno-c99-designator
  c include: ..\..\Firmware;..\MotorControl;..\ThirdParty\STM32F4xx_HAL_Driver\Inc;..\ThirdParty\FreeRTOS\Source\include;..\ThirdParty\FreeRTOS\Source\CMSIS_RTOS;..\ThirdParty\FreeRTOS\Source\portable\GCC\ARM_CM4F;..\ThirdParty\CMSIS\Include;..\ThirdParty\CMSIS\Device\ST\STM32F4xx\Include;..\ThirdParty\STM32_USB_Device_Library\Core\Inc;..\ThirdParty\STM32_USB_Device_Library\Class\CDC\Inc;..\Board\v3\Inc;..\fibre-cpp\include
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MotorControl
    ../MotorControl/: main.cpp utils.cpp arm_sin_f32.c arm_cos_f32.c low_level.cpp axis.cpp motor.cpp thermistor.cpp encoder.cpp endstop.cpp acim_estimator.cpp mechanical_brake.cpp controller.cpp foc.cpp open_loop_controller.cpp oscilloscope.cpp sensorless_estimator.cpp trapTraj.cpp pwm_input.cpp
    ../ThirdParty/CMSIS/Src/: arm_common_tables.c
  group Board/v3
    ./: startup_stm32f405xx.s
    ../Board/v3/: board.cpp
    ../Board/v3/Src/: stm32f4xx_hal_timebase_TIM.c tim.c dma.c freertos.c main.c usbd_conf.c spi.c usart.c usbd_cdc_if.c adc.c stm32f4xx_hal_msp.c usbd_desc.c stm32f4xx_it.c usb_device.c can.c system_stm32f4xx.c gpio.c i2c.c
    ../autogen/: version.c
  group Communication
    ../communication/can/: can_simple.cpp odrive_can.cpp
    ../communication/: communication.cpp ascii_protocol.cpp interface_uart.cpp interface_usb.cpp interface_i2c.cpp
  group Drivers/DRV8301
    ../Drivers/DRV8301/: drv8301.cpp
  group Drivers/STM32
    ../Drivers/STM32/: stm32_system.cpp stm32_gpio.cpp stm32_nvm.c stm32_spi_arbiter.cpp
  group Fibre
    ../fibre-cpp/: fibre.cpp channel_discoverer.cpp legacy_protocol.cpp
  group ThirdParty/FreeRTOS
    ../ThirdParty/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../ThirdParty/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../ThirdParty/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group ThirdParty/STM32_USB_Device_Library
    ../ThirdParty/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../ThirdParty/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group ThirdParty/STM32F4xx_HAL_Driver
    ../ThirdParty/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_usb.c
software components: CMSIS:CORE 5.6.0
